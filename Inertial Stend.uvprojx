# Keil uVision project Inertial Stend.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Inertial Stend
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\inc;.\Code\inc
  asm include: .\CMSIS\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Code
    ./Code/src/: ADIS.c display.c LTDC.c main.c RCC.c SPI.c L3GD20.c ADXL345.c
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group StartUp
    ./StartUp/: startup_stm32f429xx.s
